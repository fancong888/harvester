# Keil uVision project NICE.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: harvester +hex
  c flags: Optim=1
  c include: ..\02_Phy;..\02_Phy\PhySys;..\02_Phy\PhyGpio;..\02_Phy\PhyIwdg;..\02_Phy\PhyUart;..\02_Phy\OLED_I2C;..\02_Phy\PhyAdc;..\03_Obj;..\03_Obj\ObjGpio;..\03_Obj\ObjSci;..\03_Obj\ObjAdc;..\03_Obj\ObjOLED;..\04_Fun;..\08_Library;..\08_Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Jump
    ../08_Library/: startup_stm32f10x_hd.s
  group 01_Main
    ../01_Main/: Main.c
  group 02_Physical
    ../02_Phy/PhySys/: PhySys.c
    ../02_Phy/PhyAdc/: PhyAdc.c
    ../02_Phy/PhyGpio/: PhyGpio.c
    ../02_Phy/PhyIwdg/: PhyIwdg.c
    ../02_Phy/PhyUart/: PhyUart.c
    ../02_Phy/OLED_I2C/: OLED_I2C.c
  group 03_Obj
    ../03_Obj/ObjGpio/: ObjGpio.c
    ../03_Obj/ObjSci/: ObjSci.c
    ../03_Obj/ObjOLED/: ObjOLED.c
    ../03_Obj/ObjAdc/: ObjAdc.c
  group 08_Library
    ../08_Library/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
